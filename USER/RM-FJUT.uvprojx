# Keil uVision project RM-FJUT.uvprojx, settings and files
target RM-FJUT (ARM-ADS)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM-FJUT +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Bsp;..\Driver;..\Task
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Bsp
    ../Bsp/: Bsp_gpio.c Bsp_tim.c
  group Driver
    ../Driver/: Driver_Buzzer.c
  group Task
    ../Task/: Task_SysInit.c Task_Control.c
  group CORE
    ../CORE/: startup_stm32f427xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
